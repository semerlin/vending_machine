# IAR project VendoringMachine.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; __ENABLE_TRACE
  ICCARM.CCIncludePath2: F:\outsource\VendingMachine\common; F:\outsource\VendingMachine\os\include; F:\outsource\VendingMachine\os\portable\cm3; F:\outsource\VendingMachine\platform\cm3; F:\outsource\VendingMachine\platform\stm32f10x\inc; F:\outsource\VendingMachine\board; F:\outsource\VendingMachine\board\wifi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VendoringMachine.srec
  ILINK.IlinkOutputFile: VendoringMachine.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    board/: application.c application.h board.c board.h dbgserial.c dbgserial.h FreeRTOSConfig.h global.h led_motor.c led_motor.h led_net.c led_net.h main.c motorctl.c motorctl.h pinconfig.c pinconfig.h serial.c serial.h stm32f10x_cfg.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_vector.c
  group board/wifi
    board/wifi/: esp8266.c esp8266.h simple_http.c simple_http.h wifi.c wifi.h
  group common
    common/: assert.h macros.h trace.h types.h
  group mqtt
    mqtt/: mqtt.c mqtt.h
  group os
    os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os/include
    os/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group os/portable/cm3
    os/portable/cm3/: heap_2.c port.c port.h portasm.s portmacro.h
  group platform/cm3
    platform/cm3/: cm3_core.h cm3_core.s
  group platform/stm32f10x/inc
    platform/stm32f10x/inc/: stm32f10x_adc.h stm32f10x_crc.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_rcc.h stm32f10x_scb.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_usart.h stm32f10x_wwdg.h
  group platform/stm32f10x/src
    platform/stm32f10x/src/: stm32f10x_adc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_scb.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c stm32f10x_wwdg.c
